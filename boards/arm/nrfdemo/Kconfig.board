## boards/arm/nrfdemo/Kconfig.defconfig
```kconfig
if BOARD_NRFDEMO

config BOARD
	default "nrfdemo"

config BT_CTLR
	default BT

endif # nrfdemo
```
